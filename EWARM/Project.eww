<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\4Q_DC_Motor-Speed-Controller.ewp</path>
  </project>
  <batchBuild />
</workspace>
